# IAR project Backup (2) of LQ_K66FX_SmartCar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 Freescale MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4
  ICCARM.CCIncludePath2: src\Includes; src\User; src\Project_Setting; src\Project_Setting\Startup; src\Project_Setting\Linker_Files; src\Libs; src\ARM_math\BasicMathFunctions; src\ARM_math\CommonTables; src\ARM_math\ComplexMathFunctions; src\ARM_math\ControllerFunctions; src\ARM_math\FastMathFunctions; src\ARM_math\FilteringFunctions; src\ARM_math\MatrixFunctions; src\ARM_math\StatisticsFunctions; src\ARM_math\SupportFunctions; src\ARM_math\TransformFunctions
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LQ_K66FX_OLED.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: src\Project_Setting\Linker_Files\LQK66RAM256K.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  OBJCOPY.OOCOutputFile: LQ_K66FX_SmartCar.hex
  ILINK.IlinkIcfFile: src\Project_Setting\Linker_Files\LQK66FLASH1M.icf
  group Driver/ADC
    src/Source/: ADC.c
    src/Includes/: ADC.h
  group Driver/DialSwitch
    src/User/: DialSwitch.c DialSwitch.h
  group Driver/DMA
    src/Source/: DMA.c
    src/Includes/: DMA.h
  group Driver/findtrack
    src/User/: findtrack.c findtrack.h
  group Driver/FTM
    src/Source/: FTM.c
    src/Includes/: FTM.h
  group Driver/GPIO
    src/Source/: GPIO.c
    src/Includes/: GPIO.h GPIO_Cfg.h
  group Driver/IIC
    src/Source/: I2C.c
    src/Includes/: I2C.h
  group Driver/LPTMR
    src/Source/: LPTMR.c
    src/Includes/: Lptmr.h
  group Driver/magnet
    src/User/: magnet.c magnet.h
  group Driver/MOTOR
    src/User/: motor.c motor.h
  group Driver/PIT
    src/Source/: PIT.c
    src/Includes/: PIT.h
  group Driver/PLL
    src/Source/: PLL.c
    src/Includes/: PLL.h
  group Driver/RTC
    src/Source/: RTC.c
    src/Includes/: RTC.h
  group Driver/STEER
    src/User/: steer.c steer.h
  group Driver/Systick
    src/Source/: Systick.c
    src/Includes/: Systick.h
  group Driver/Test
    src/User/: Test.c Test.h
  group Driver/TrackType
    src/User/: TrackType.c TrackType.h
  group Driver/UART
    src/Source/: UART.c
    src/Includes/: UART.h
  group Driver/Vectors
    src/Source/: vectors.c
    src/Includes/: vectors.h
  group Driver/WDOG
    src/Source/: wdog.c
    src/Includes/: wdog.h
  group header
    src/Libs/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h MK66F18.h
  group Include
    src/Source/: common.c
    src/Includes/: common.h
    src/User/: include.h
  group Start up
    src/Project_Setting/Startup/: crt0.s start.c
  group User
    src/Source/: LQ12864.c LQKEY.c LQLED.c
    src/Includes/: LQ12864.h LQKEY.h LQLED.h
    src/User/: LQ_SGP18T.c LQ_SGP18T.h LQlogo.h LQMT9V034.c LQMT9V034.h main.c picture.h
